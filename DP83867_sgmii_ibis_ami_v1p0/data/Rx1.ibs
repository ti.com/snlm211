[IBIS Ver]   5.0
[File Name]   Rx1.ibs
[File Rev]   1.0
[Component]   Rx1
[Manufacturer] My Company
[Package]
R_pkg  0.0   NA   NA
L_pkg  0.0   NA   NA
C_pkg  0.0   NA   NA
[Pin]   signal_name   model_name   R_pin L_pin  C_pin
2p   Rx1_2p   Rx1
2n   Rx1_2n   Rx1
[Diff_Pin] inv_pin vdiff tdelay_typ tdelay_min tdelay_max
2p   2n   NA   NA   NA   NA
[Model] Rx1
Model_type Input
C_comp 0p 0p 0p
Vinh = 0.25
Vinl = -0.25
[Temperature_Range] 25 125 0
[Voltage Range] 1.0 1.0 1.0
[Algorithmic Model]
Executable Windows_cl16.00.30319.01_64 Rx1_x64.dll Rx1.ami
Executable Windows_cl16.00.30319.01_32 Rx1.dll Rx1.ami
[End Algorithmic Model]
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| Models and submodels in the file (1): Rx1 (Input)
